FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append += " \
        file://0119-mtk-wifi-mt76-mt7996-fix-csi-band-idx.patch \
        "
